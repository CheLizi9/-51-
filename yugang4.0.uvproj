# Keil uVision project yugang4.0.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: yugang4.0 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c lcd12864.c lcd12864.h ds18b20.h ds18b20.c adc0832.h adc0832.c eeprom_isp.c eeprom_isp.h all_define.h bujin.h ds1302.h
